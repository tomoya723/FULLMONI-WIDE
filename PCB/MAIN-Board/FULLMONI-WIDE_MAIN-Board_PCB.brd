# Repository tomoya723/FULLMONI-WIDE

File README.md:

<br>
## FULLMONI-WIDE
<br>
<br>
## プロジェクト概要
FULLMONI-WIDEは自動車用デジタルメーターのオープンハードウェアプロジェクト。  
ECUからCANバス経由で送られる車両情報を受信し、800×256ドットのフルカラー液晶に表示する。  
マツダロードスターNA用の専用筐体に加え、汎用筐体も対象とする。  

## 技術スタック
- **マイコン:** ルネサスRX72N（RXv3コア、240MHz、4MB Flash、1MB SRAM、GLCDC内蔵）  
- **IDE:** Renesas e²studio + GCC-RX / VS Code対応  
- **グラフィック:** LVGL 8.3（EEZ Studio）  
- **ドライバ:** Smart Configurator生成コードとFITモジュール  
- **通信:** USB CDC（ファームウェア更新・パラメータ設定）、CAN（車両データ）  
- **周辺機能:** I²C、ADC、タイマ、外部EEPROM、Neopixel対応LED  
- **ホストアプリ:** .NET 8.0 WPF（Windows）、Jetpack Compose（Android）  

## ディレクトリ構成
- `Bootloader/` – USB CDC対応ブートローダー（ファームウェア更新用）  
- `Firmware/` – マイコン用ファームウェア（C言語）  
- `HostApp/` – Windows/Android ホストアプリケーション  
- `Hardware/` – 回路図、PCB、筐体設計ファイル  
- `IMG/` – プロジェクト関連画像  
- `debug_env/` – BusMasterによるCANシミュレーション環境  
- `docs/` – プロジェクトドキュメント  
- `schemas/` – リリースマニフェストのJSONスキーマ・サンプル  
- `tools/` – ビルド・リリース用スクリプト  
- `.github/` – CI/CD設定  
- `release-manifest.json` – リリース情報（バージョン、ファイルハッシュ等）  
- その他プロジェクト設定ファイル、ライセンス、README  

## 主要機能
- エンジン回転数、車速、温度、圧力、電圧のリアルタイム表示  
- 800×256ドット16bitカラー液晶表示、輝度調整機能  
- シフトライト兼警告用RGB LED（Neopixel）×8  
- 外部EEPROMによる走行距離・トリップログ記録  
- アナログ入力最大8ch、車速パルス入力対応  
- **USB CDC経由のファームウェア更新**（Windows/Androidアプリ対応）  
- **パラメータ設定コンソール**（タイヤサイズ、ギア比、警告閾値、シフトRPM）  
- **CAN設定カスタマイズ**（CAN ID、データフィールド定義、ECUプリセット対応）  
- 回路・基板設計をMITライセンスで公開  

## ホストアプリケーション

### Windows Terminal（.NET 8.0 WPF）
- **モダンUI**: WPF-UI (Fluent Design) によるダークテーマ、英語UI
- パラメータ設定GUI（タイヤサイズ、ギア比プリセット、警告設定、シフトRPM）
- CAN設定カスタマイズ（CAN ID、データフィールド、ECUプリセット）
- 起動画面カスタマイズ（765×256 BMP画像）
- ファームウェア更新機能（BINファイル選択→高速転送 約268KB/s）
- Bootloaderモード自動検出（ファームウェア破損時の復旧対応）

### Android Terminal（Jetpack Compose）
- USB Serial通信によるパラメータ設定
- CAN設定カスタマイズ（CAN ID、データフィールド）
- 起動画面カスタマイズ（765×256画像、読み取り/書き込み/保存）
- ファームウェア更新機能
- Material 3 ダークテーマ

詳細は [HostApp/README.md](HostApp/README.md) を参照。

## 特徴的な設計思想
- 古い車両の絶版部品を現代技術で再生  
- シンプルかつ純正然とした外観を志向  
- 機能性の追求を美観と捉える思想  
- メイン基板・LED基板・インターフェース基板に分けたモジュール設計  
- ハード・ソフトともにオープンソース公開  

## 開発ロードマップ（簡易版）
今後の改善方針と優先順位を示すロードマップ。

- **優先度 高**
  - TypeNモデル開発
  - データ処理・表示処理リファクタリング
  - ~~ユーザリプロ対応~~ ✅ 完了（USB CDC経由ファームウェア更新）
  - ~~ドキュメント拡充~~ ✅ 完了（Bootloader/Firmware/HostApp README）

- **優先度 中**
  - セキュアリプロ対応（OTA）
  - テスト環境強化（BusMasterシナリオ整理、ユニットテスト追加）
  - 拡張ガイド整備（センサ追加手順、GUIテーマカスタマイズ例）

- **優先度 低**
  - 利用事例共有（実車取付例、動作動画）

## EAGLE design PCB/MAIN-Board/FULLMONI-WIDE_MAIN-Board_PCB.brd

File PCB/README.md:

# Schematic & PCB Files
## MAIN-Board
 SCH : [FULLMONI-WIDE_MAIN-Board_SCH v70.pdf](https://github.com/tomoya723/FULLMONI-WIDE/blob/main/PCB/FULLMONI-WIDE_MAIN-Board_SCH%20v70.pdf)<br>
 &emsp;&emsp; https://a360.co/4059OwM<br>
 PCB : https://a360.co/4acejtW<br>
 3D : https://a360.co/3PSdNs1<br>
## LED-Board1
 SCH : [FULLMONI-WIDE_LED-Board1_SCH v40.pdf](https://github.com/tomoya723/FULLMONI-WIDE/blob/main/PCB/FULLMONI-WIDE_LED-Board1_SCH%20v40.pdf)<br>
&emsp;&emsp; https://a360.co/4fYChtY<br>
 PCB : https://a360.co/40t23C2<br>
 3D : https://a360.co/4avyaEV<br>
## IF-Board1
 SCH : [FULLMONI-WIDE_IF-Board1_SCH v2.pdf](https://github.com/tomoya723/FULLMONI-WIDE/blob/main/PCB/FULLMONI-WIDE_IF-Board1_SCH%20v2.pdf)<br>
&emsp;&emsp; https://a360.co/4heQZyd<br>
 PCB : https://a360.co/4jgQo0P<br>
 3D : https://a360.co/4gSbPna<br>

Parts:
BT1: 120591-1
C1, C2, C3, C5, C6, C7, C8, C9, C10, C13, C14, C16, C17: SC2012-104; CAPC2012X110
C4: SC2012-105; CAPC2012X110
C11, C12: SC2012-7.5p; CAPC2012X110
C18: SC3216-106; CAPC3216X135
CN1: 500075-1517
CN2: 105057-0001
CN3: FH12A-40S-0.5SH
D1, D2: BAT54S; SOT23
D3: 1SS321
FB1: BLM21PG331; BEADC2012X105N
J1: TST-107-01-T-D; SAMTEC-TST-107-01-X-D
JP1, JP2: PINHD-1X2/90; 1X02/90
JP3: PINHD-2X20; 2X20
NF1, NF2: B82787C0513H002; ACT45B-510-2P
R1, R2, R3, R4, R8, R9, R21, R22, R23, R31, R32, R34: SR2012-N.C; RESC2012X65
R5: SR2012-152(Peri)/N.C(Host); RESC2012X65
R6, R7, R36: SR2012-100; RESC2012X65
R10, R11, R14, R20, R27, R28, R29: SR2012-103; RESC2012X65
R12: SR2012-302(Peri)/N.C(Host); RESC2012X65
R13, R19, R30: SR2012-472; RESC2012X65
R15, R17, R24, R25: SR2012-0; RESC2012X65
R16, R18: 3502120RFT; RESC5025X71
R26: SR2012-N.C(Peri)/0(Host); RESC2012X65
R33: SR2012-470; RESC2012X65
R35: SR2012-220; RESC2012X65
RM1, RM2, RM3: CAY16-103J4LF; CN1J4TTD000J
RM4, RM5: CAY16-472J4LF; CN1J4TTD000J
RM6, RM7, RM8, RM9: CAY16-470J4LF; CN1J4TTD000J
SW1, SW2: CJS-1200TB; CJS-1200B
U1: ISL61861BIBZ
U2: BD5230G-2; BD5230G-1
U3, U4: SN65HVD230DR; SO-8
U5: 74VHCV541FT; 74VHCV54XFT
U6: R5F572NNXXFP
U7: ATTINY85-20SU; 8S2_ATM-M
U9: BR24A16F-WLB
X1: CSTNE24M0VH3C000
X2: FC-135 32.7680KA-E3; FC-135

Connections:
+3.3VD: C1.1, C7.1, C8.1, C9.1, C10.1, C16.1, C17.1, C18.1, CN3.37 (VDD1), CN3.38 (VDD2), CN3.39 (VDD3), CN3.40 (VDD4), D1.2 (C2), D2.2 (C2), D3.2 (A2), FB1.1, J1.8, JP3.37, JP3.38, JP3.39, JP3.40, R19.2, R27.2, R30.2, RM1.P$5 (5), RM1.P$6 (6), RM1.P$7 (7), RM1.P$8 (8), RM2.P$5 (5), RM2.P$6 (6), RM2.P$7 (7), RM2.P$8 (8), RM3.P$5 (5), RM3.P$6 (6), RM3.P$7 (7), RM3.P$8 (8), RM4.P$5 (5), RM4.P$6 (6), RM4.P$7 (7), RM4.P$8 (8), RM5.P$5 (5), RM5.P$6 (6), RM5.P$7 (7), RM5.P$8 (8), SW1.3, SW2.3, U2.2 (VDD), U3.3 (VCC), U4.3 (VCC), U6.14 (VCC), U6.60 (VCC), U7.8 (VCC), U9.8 (VCC); also elsewhere on the board
+5VD: C5.1, R1.2, R2.2, R3.2, R4.2, U1.2 (VIN1), U1.3 (VIN2); also elsewhere on the board
B1: CN3.24 (B1), JP3.24, RM7.P$8 (8)
B2: CN3.25 (B2), JP3.25, RM6.P$5 (5)
B3: CN3.27 (B3), JP3.27, RM6.P$6 (6)
B4: CN3.28 (B4), JP3.28, RM6.P$7 (7)
B5: CN3.29 (B5), JP3.29, RM6.P$8 (8)
CAN0-H: NF1.2; also elsewhere on the board
CAN0-L: NF1.1; also elsewhere on the board
CAN1-H: NF2.2; also elsewhere on the board
CAN1-L: NF2.1; also elsewhere on the board
CLK: CN3.3 (CLK), JP3.3, R35.2
CR2032: BT1.2 (+), BT1.3 (+1), D3.1 (A1)
CRX0: RM2.P$4 (4), U3.4 (R), U6.17 (CRX0)
CRX1: RM2.P$2 (2), U4.4 (R), U6.31 (CRX1)
CTX0: RM2.P$3 (3), U3.1 (D), U6.18 (CTX0)
CTX1: RM2.P$1 (1), U4.1 (D), U6.25 (CTX1)
DE: CN3.35 (DE), JP3.35, R33.2
DGND: BT1.1 (ー), C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, C9.2, C10.2, C11.1, C12.1, C13.1, C14.2, C16.2, C17.2, C18.2, CN1.5 (GND), CN1.6 (TH-1), CN1.7 (TH-2), CN2.4 (GND), CN2.F1 (GND), CN2.F2 (GND), CN2.F3 (GND), CN3.1 (VSS1), CN3.2 (VSS2), CN3.4 (VSS3), CN3.5 (VSS4), CN3.7 (R0), CN3.10 (VSS5), CN3.14 (VSS6), CN3.18 (VSS7), CN3.22 (VSS8), CN3.23 (B0), CN3.26 (VSS9), CN3.30 (VSS10), CN3.32 (VSS11), CN3.34 (VSS12), D1.1 (A1), D2.1 (A1), J1.2, J1.12, J1.14, JP3.1, JP3.2, JP3.4, JP3.5, JP3.7, JP3.10, JP3.14, JP3.18, JP3.22, JP3.23, JP3.26, JP3.30, JP3.32, JP3.34, R10.1, R11.1, R12.1, R15.1, R17.1, R20.1, R28.1, R29.1, SW1.1, SW2.1, U1.1 (GND), U2.3 (GND), U3.2 (GND), U4.2 (GND), U6.12 (VSS), U6.38 (VSS_USB), U6.62 (VSS), U7.4 (GND), U9.4 (GND), U9.7 (WP), X1.2; also elsewhere on the board
EMLE: J1.4, R29.2, U6.2 (EMLE)
EXTAL: U6.13 (EXTAL), X1.3
G0: CN3.15 (G0), JP3.15, RM8.P$6 (6)
G1: CN3.16 (G1), JP3.16, RM8.P$7 (7)
G2: CN3.17 (G2), JP3.17, RM8.P$8 (8)
G3: CN3.19 (G3), JP3.19, RM7.P$5 (5)
G4: CN3.20 (G4), JP3.20, RM7.P$6 (6)
G5: CN3.21 (G5), JP3.21, RM7.P$7 (7)
LCD_B/L: U6.4 (MTIOC3C(LCD_B/L)); also elsewhere on the board
LCD_CLK: R35.1, U6.55 (LCD_CLK)
LCD_DATA0: RM9.P$4 (4), U6.61 (LCD_DATA0)
LCD_DATA1: RM9.P$3 (3), U6.63 (LCD_DATA1)
LCD_DATA2: RM9.P$2 (2), U6.64 (LCD_DATA2)
LCD_DATA3: RM9.P$1 (1), U6.65 (LCD_DATA3)
LCD_DATA4: RM8.P$4 (4), U6.66 (LCD_DATA4)
LCD_DATA5: RM8.P$3 (3), U6.67 (LCD_DATA5)
LCD_DATA6: RM8.P$2 (2), U6.68 (LCD_DATA6)
LCD_DATA7: RM8.P$1 (1), U6.69 (LCD_DATA7)
LCD_DATA8: RM7.P$4 (4), U6.70 (LCD_DATA8)
LCD_DATA9: RM7.P$3 (3), U6.71 (LCD_DATA9)
LCD_DATA10: RM7.P$2 (2), U6.72 (LCD_DATA10)
LCD_DATA11: RM7.P$1 (1), U6.73 (LCD_DATA11)
LCD_DATA12: RM6.P$4 (4), U6.74 (LCD_DATA12)
LCD_DATA13: RM6.P$3 (3), U6.75 (LCD_DATA13)
LCD_DATA14: RM6.P$2 (2), U6.76 (LCD_DATA14)
LCD_DATA15: RM6.P$1 (1), U6.77 (LCD_DATA15)
LCD_TCON0: R31.1, U6.56 (LCD_TCON0)
LCD_TCON1: R32.1, U6.57 (LCD_TCON1)
LCD_TCON2: R33.1, U6.58 (LCD_TCON2)
LCD_TCON3: R34.1, U6.59 (LCD_TCON3)
MD: J1.7, R13.2, U6.7 (MD/FINED)
unnamed: CN3.6 (N.C1), JP3.6
unnamed: NF1.3, R16.2, U3.7 (CANH)
unnamed: NF2.3, R18.2, U4.7 (CANH)
unnamed: R15.2, U3.8 (RS)
unnamed: JP1.1, NF1.4, U3.6 (CANL)
unnamed: JP1.2, R16.1
unnamed: JP2.2, R18.1
unnamed: JP2.1, NF2.4, U4.6 (CANL)
unnamed: R17.2, U4.8 (RS)
unnamed: R26.1, U1.4 (EN)
unnamed: CN2.1 (VBUS), U1.6 (OUT1), U1.7 (OUT2), U1.8 (OUT3)
unnamed: R20.2, R23.1, U5.7 (A)
unnamed: R22.1, U5.17 (Y)
unnamed: R14.1, SW2.2
unnamed: R13.1, SW1.2
unnamed: R36.1, U7.2 (PB3(NEO_DATA))
unnamed: CN1.3 (D+), CN2.3 (DP), R7.1
unnamed: CN1.2 (D-), CN2.2 (DM), R6.1
unnamed: CN1.1 (VBUS), R5.1
unnamed: C6.1, U2.5 (CT)
N.C2: CN3.31 (N.C2), JP3.31, R34.2
N.C3: CN3.33 (N.C3), JP3.33, R32.2
N.C4: CN3.36 (N.C4), JP3.36, R31.2
NEO-DATA: R36.2; also elsewhere on the board
OE: R30.1, U6.29 (P17); also elsewhere on the board
R1: CN3.8 (R1), JP3.8, RM9.P$5 (5)
R2: CN3.9 (R2), JP3.9, RM9.P$6 (6)
R3: CN3.11 (R3), JP3.11, RM9.P$7 (7)
R4: CN3.12 (R4), JP3.12, RM9.P$8 (8)
R5: CN3.13 (R5), JP3.13, RM8.P$5 (5)
RST: J1.13, R19.1, U2.1 (VOUT), U6.10 (RES#), U7.1 (PB5(RESET)); also elsewhere on the board
RXD8: RM1.P$1 (1), U5.18 (Y), U6.46 (RXD8)
RXD9: R22.2, R24.2, RM1.P$3 (3), U6.54 (RXD9)
RXD9-2: R24.1; also elsewhere on the board
SCI0_RXD: R1.1, R8.1; also elsewhere on the board
SCI0_TXD: R2.1, U5.14 (Y); also elsewhere on the board
SCI1_RXD: R3.1, R9.1; also elsewhere on the board
SCI1_RXD1: C3.1, D2.3 (C1A2), R9.2, R11.2, U5.3 (A)
SCI1_RXD2: C2.1, D1.3 (C1A2), R8.2, R10.2, U5.2 (A)
SCI1_TXD: R4.1, U5.13 (Y); also elsewhere on the board
SCL0: RM5.P$2 (2), U6.34 (SCL0), U9.6 (SCL)
SCL1: RM4.P$2 (2), U6.27 (SCL1), U7.7 (PB2(SCL))
SDA0: RM5.P$1 (1), U6.33 (SDA0), U9.5 (SDA)
SDA1: RM4.P$1 (1), U6.28 (SDA1), U7.5 (PB0(SDA))
TCK: J1.1, R28.2, U6.21 (TCK)
TDO: J1.5, RM3.P$3 (3), U6.22 (TDO)
TMS: J1.9, RM3.P$2 (2), U6.19 (TMS)
TRST: J1.3, U6.16 (TRST#)
TSI: J1.11, RM3.P$1 (1), U6.20 (TDI)
TXD8: R21.2, RM1.P$2 (2), U5.6 (A), U6.45 (TXD8/UB)
TXD8/UB: J1.6, R21.1
TXD9: R23.2, R25.2, RM1.P$4 (4), U6.53 (TXD9)
TXD9-2: R25.1; also elsewhere on the board
UPSEL: R14.2, U6.15 (UPSEL)
USB0_DM: R6.2, U6.36 (USB0_DM)
USB0_DP: R7.2, U6.37 (USB0_DP)
USB0_OVRCURB: R27.1, U1.5 (FAULT), U6.26 (USB0_OVRCURB)
USB0_VBUS/VBUSEN: C4.1, R5.2, R12.2, R26.2, U6.30 (USB0_VBUS/VBUSEN)
VBATT: D3.3 (C), U6.6 (VBATT)
VCC_USB: C14.1, FB1.2, U6.35 (VCC_USB)
VCL: C13.2, U6.5 (VCL)
XCIN: C12.2, U6.8 (XCIN), X2.1
XCOUT: C11.2, U6.9 (XCOUT), X2.2
XTAL: U6.11 (XTAL), X1.1

Notes on the sheet:
LCD I/F
16kByte
EEPROM
CAN 2ch
SCI 2ch
Neopixel Driver
USB(Peri/Host)
P-O-R
※UB = High : Boot mode USB
CSTNE 24MHz -40～+125℃
32.768kHz -40～+85℃
Comm & LCD I/F, LED Drv
VBUS Io = 150mA

Parts:
C19, C20, C21, C22, C23, C24, C25, C26: SC2012-N.C; CAPC2012X110
C27, C28, C29, C30, C31, C32, C33, C34, C35, C36, C37, C38, C39, C40, C41, C42, C43, C44, C45, C46, C47, C50: SC2012-104; CAPC2012X110
C48: SC2012-394; CAPC2012X110
C49: SC2012-105; CAPC2012X110
CN8: S2B-XH-A(LF)(SN); HDR-02/RA
D4, D5, D6, D7, D8, D9, D10, D11, D25: BAT54S; SOT23
FB2, FB3, FB4: BLM21PG331; BEADC2012X105N
R37, R38, R39, R40, R41, R42, R43, R47, R49, R51, R53, R55, R56, R58, R65, R67, R68, R69, R70, R71, R72, R73, R74, R75: SR2012-N.C; RESC2012X65
R44: RLF3SJ0.1Ω; RLF3SJ
R45, R46, R48, R50, R52, R57: SR2012-123D; RESC2012X65
R54, R76, R77, R78, R79, R80, R81, R82, R83: SR2012-0; RESC2012X65
R59: RLF3SJ560Ω; RLF3SJ
R60, R61, R62, R63, R64, R66: SR2012-302D; RESC2012X65
R84, R85, R86, R87, R88, R89, R90, R91, R92, R94: SR2012-203; RESC2012X65
R93, R140: SR2012-103; RESC2012X65
U6: R5F572NNXXFP
U10, U11: MCP6024-I/ST
U12: LM4861M; LM4818MX

Connections:
+3.3VD: FB2.1, FB3.1; also elsewhere on the board
+5VD: FB4.1, R93.2; also elsewhere on the board
+5VREF: R37.1, R38.1, R39.1, R40.1, R41.1, R42.1, R43.1; also elsewhere on the board
A/D0: C19.1, R37.2, R45.1; also elsewhere on the board
A/D1: C20.1, R38.2, R47.1; also elsewhere on the board
A/D2: C21.1, R39.2, R49.1; also elsewhere on the board
A/D3: C22.1, R40.2, R51.1; also elsewhere on the board
A/D4: C23.1, R41.2, R53.1; also elsewhere on the board
A/D5: C24.1, R42.2, R55.1; also elsewhere on the board
A/D6: C25.1, R43.2, R56.1; also elsewhere on the board
A/D7: C26.1, R58.1; also elsewhere on the board
AGND: C27.2, C28.2, C29.2, C30.2, C31.2, C32.2, C33.2, C34.2, C35.2, C36.2, C37.2, C38.2, C39.2, C40.2, C41.2, C42.2, C43.2, C44.2, C45.2, C46.2, C47.2, C49.2, C50.2, D4.1 (A1), D5.1 (A1), D6.1 (A1), D7.1 (A1), D8.1 (A1), D9.1 (A1), D10.1 (A1), D11.1 (A1), R60.1, R61.1, R62.1, R63.1, R64.1, R65.1, R66.1, R67.1, R68.1, R69.1, R70.1, R71.1, R72.1, R73.1, R74.1, R75.1, U6.3 (AVSS1), U6.94 (VREFL0), U6.99 (AVSS0), U10.11 (GND), U11.11 (GND), U12.7 (GND); also elsewhere on the board
AN0: C35.1, D4.3 (C1A2), R84.2, U6.95 (AN000)
AN1: C36.1, D5.3 (C1A2), R85.2, U6.93 (AN001)
AN2: C37.1, D6.3 (C1A2), R86.2, U6.92 (AN002)
AN3: C38.1, D7.3 (C1A2), R87.2, U6.91 (AN003)
AN4: C39.1, D8.3 (C1A2), R88.2, U6.90 (AN004)
AN5: C40.1, D9.3 (C1A2), R89.2, U6.89 (AN005)
AN6: C41.1, D10.3 (C1A2), R90.2, U6.88 (AN006)
AN7: C42.1, D11.3 (C1A2), R91.2, U6.87 (AN007)
AVCC0: C43.1, C44.1, C46.1, D4.2 (C2), D5.2 (C2), D6.2 (C2), D7.2 (C2), D8.2 (C2), D9.2 (C2), D10.2 (C2), D11.2 (C2), D25.2 (C2), FB2.2, U6.97 (AVCC0), U10.4 (VDD), U11.4 (VDD)
AVCC1: C47.1, FB3.2, U6.1 (AVCC1)
BELTS: R52.1; also elsewhere on the board
BREAK: R48.1; also elsewhere on the board
CHARGE: R46.1; also elsewhere on the board
CHECK_HEAT: R50.1; also elsewhere on the board
DA1: C48.1, U6.100 (DA1)
FUEL.M: R59.2, R140.2; also elsewhere on the board
IG1: R44.1, R57.1; also elsewhere on the board
LUMINANCE: R54.1; also elsewhere on the board
unnamed: R68.2, R76.1, U10.6 (-)
unnamed: R92.2, R94.1, U12.4 (IN-)
unnamed: R44.2, R59.1
unnamed: C26.2, C34.1, D25.3 (C1A2), R58.2, R67.2, R140.1, U11.10 (+)
unnamed: C19.2, C27.1, R45.2, R60.2, U10.5 (+)
unnamed: R69.2, R77.1, U10.2 (-)
unnamed: C20.2, C28.1, R46.2, R47.2, R61.2, U10.3 (+)
unnamed: R70.2, R78.1, U10.13 (-)
unnamed: C21.2, C29.1, R48.2, R49.2, R62.2, U10.12 (+)
unnamed: R71.2, R79.1, U10.9 (-)
unnamed: C22.2, C30.1, R50.2, R51.2, R63.2, U10.10 (+)
unnamed: R72.2, R80.1, U11.6 (-)
unnamed: C23.2, C31.1, R52.2, R53.2, R64.2, U11.5 (+)
unnamed: R73.2, R81.1, U11.2 (-)
unnamed: C24.2, C32.1, R54.2, R55.2, R65.2, U11.3 (+)
unnamed: R74.2, R82.1, U11.13 (-)
unnamed: C25.2, C33.1, R56.2, R57.2, R66.2, U11.12 (+)
unnamed: R75.2, R83.1, U11.9 (-)
unnamed: R76.2, R84.1, U10.7 (OUT)
unnamed: R77.2, R85.1, U10.1 (OUT)
unnamed: R78.2, R86.1, U10.14 (OUT)
unnamed: R79.2, R87.1, U10.8 (OUT)
unnamed: R80.2, R88.1, U11.7 (OUT)
unnamed: R81.2, R89.1, U11.1 (OUT)
unnamed: R82.2, R90.1, U11.14 (OUT)
unnamed: R83.2, R91.1, U11.8 (OUT)
unnamed: CN8.1, R94.2, U12.5 (VO1)
unnamed: C50.1, FB4.2, U12.6 (VDD)
unnamed: C48.2, R92.1
unnamed: C49.1, U12.2 (B/P), U12.3 (IN+)
unnamed: CN8.2, U12.8 (VO2)
unnamed: R93.1, U12.1 (S/D)
VREF0: C45.1, U6.96 (VREFH0); also elsewhere on the board

Notes on the sheet:
ANALOG-IN 8ch
SP-OUT 1ch
Analog I/F
15→3Vdc fc = 132Hz
3→3Vdc fc = 79.5Hz
3→3Vdc

Parts:
C51, C52, C53, C54, C55, C56, C57, C58, C59, C60: SC2012-102; CAPC2012X110
C61, C62: SC2012-104; CAPC2012X110
D12, D13, D14, D15, D16, D17, D18, D19, D20, D21: BAT54S; SOT23
Q1, Q2, Q3, Q4: BM2LE250FJ-C
Q5, Q6, Q7, Q8: BV1LE080EFJ-C
R95, R96, R97: SR2012-102; RESC2012X65
R98, R99, R100, R101, R102, R103, R104, R109, R111, R113, R115, R119, R121, R122, R123, R124, R125, R126, R127, R128, R129, R130: SR2012-N.C; RESC2012X65
R105, R106, R107, R108, R110, R112, R114, R116, R120: SR2012-333; RESC2012X65
R117, R118: SR2012-0; RESC2012X65
RM10, RM11, RM12: CAY16-103J4LF; CN1J4TTD000J
U5, U13: 74VHCV541FT; 74VHCV54XFT
U6: R5F572NNXXFP

Connections:
+3.3VD: C61.2, C62.2, D12.2 (C2), D13.2 (C2), D14.2 (C2), D15.2 (C2), D16.2 (C2), D17.2 (C2), D18.2 (C2), D19.2 (C2), D20.2 (C2), D21.2 (C2), U5.20 (VCC), U13.20 (VCC); also elsewhere on the board
+5VD: R95.2, R96.2, R97.2, R98.2, R99.2, R100.2, R101.2, R102.2, R103.2, R104.2; also elsewhere on the board
BELTS: R111.1; also elsewhere on the board
BREAK: R115.1; also elsewhere on the board
CHARGE: R119.1; also elsewhere on the board
CHECK_HEAT: R113.1; also elsewhere on the board
DGND: C51.2, C52.2, C53.2, C54.2, C55.2, C56.2, C57.2, C58.2, C59.2, C60.2, C61.1, C62.1, D12.1 (A1), D13.1 (A1), D14.1 (A1), D15.1 (A1), D16.1 (A1), D17.1 (A1), D18.1 (A1), D19.1 (A1), D20.1 (A1), D21.1 (A1), Q1.5 (GND2), Q1.7 (GND1), Q2.5 (GND2), Q2.7 (GND1), Q3.5 (GND2), Q3.7 (GND1), Q4.5 (GND2), Q4.7 (GND1), Q5.5 (GND1), Q5.6 (GND2), Q5.7 (GND3), Q5.8 (GND4), Q6.5 (GND1), Q6.6 (GND2), Q6.7 (GND3), Q6.8 (GND4), Q7.5 (GND1), Q7.6 (GND2), Q7.7 (GND3), Q7.8 (GND4), Q8.5 (GND1), Q8.6 (GND2), Q8.7 (GND3), Q8.8 (GND4), R121.1, R122.1, R123.1, R124.1, R125.1, R126.1, R127.1, R128.1, R129.1, R130.1, RM10.P$1 (1), RM10.P$2 (2), RM10.P$3 (3), RM10.P$4 (4), RM11.P$1 (1), RM11.P$2 (2), RM11.P$3 (3), RM11.P$4 (4), RM12.P$1 (1), RM12.P$2 (2), RM12.P$3 (3), RM12.P$4 (4), U5.8 (A), U5.9 (A), U5.10 (GND), U5.19 (G2#), U13.10 (GND), U13.19 (G2#); also elsewhere on the board
DI0: R95.1, R105.1; also elsewhere on the board
DI1: R96.1, R106.1; also elsewhere on the board
DI2: R97.1, R107.1; also elsewhere on the board
DI3: R98.1, R108.1; also elsewhere on the board
DI4: R99.1, R110.1; also elsewhere on the board
DI5: R100.1, R112.1; also elsewhere on the board
DI6: R101.1, R114.1; also elsewhere on the board
DI7: R102.1, R116.1; also elsewhere on the board
DI8: R103.1, R118.1; also elsewhere on the board
DI9: R104.1, R120.1; also elsewhere on the board
DII0: RM10.P$8 (8), U6.24 (MTCLKA(SW_A)), U13.11 (Y)
DII1: RM10.P$7 (7), U6.23 (MTCLKB(SW_B)), U13.12 (Y)
DII2: RM10.P$6 (6), U6.86 (PD0), U13.13 (Y)
DII3: RM10.P$5 (5), U6.85 (PD1), U13.14 (Y)
DII4: RM11.P$8 (8), U6.84 (PD2), U13.15 (Y)
DII5: RM11.P$7 (7), U6.83 (PD3), U13.16 (Y)
DII6: RM11.P$6 (6), U6.82 (PD4), U13.17 (Y)
DII7: RM11.P$5 (5), U6.81 (PD5), U13.18 (Y)
DII8: RM12.P$8 (8), U5.15 (Y), U6.80 (PD6/MTIOC8A(SPEED))
DII9: RM12.P$7 (7), U5.16 (Y), U6.79 (PD7)
DO0: Q1.3 (IN2), U6.44 (P50)
DO1: Q1.1 (IN1), U6.43 (P51)
DO1-0: Q1.6 (OUT2); also elsewhere on the board
DO1-1: Q1.8 (OUT1); also elsewhere on the board
DO1-2: Q2.6 (OUT2); also elsewhere on the board
DO1-3: Q2.8 (OUT1); also elsewhere on the board
DO1-4: Q3.6 (OUT2); also elsewhere on the board
DO1-5: Q3.8 (OUT1); also elsewhere on the board
DO1-6: Q4.6 (OUT2); also elsewhere on the board
DO1-7: Q4.8 (OUT1); also elsewhere on the board
DO2: Q2.3 (IN2), U6.42 (P52)
DO2-0: Q5.9 (OUT), Q5.P$1 (OUT), Q5.P$2 (OUT); also elsewhere on the board
DO2-1: Q6.9 (OUT), Q6.P$1 (OUT), Q6.P$2 (OUT); also elsewhere on the board
DO2-2: Q7.9 (OUT), Q7.P$1 (OUT), Q7.P$2 (OUT); also elsewhere on the board
DO2-3: Q8.9 (OUT), Q8.P$1 (OUT), Q8.P$2 (OUT); also elsewhere on the board
DO3: Q2.1 (IN1), U6.41 (P53)
DO4: Q3.3 (IN2), U6.40 (P54)
DO5: Q3.1 (IN1), U6.39 (P55)
DO6: Q4.3 (IN2), U6.52 (PC0)
DO7: Q4.1 (IN1), U6.51 (PC1)
DO8: Q5.1 (IN), U6.50 (PC2)
DO9: Q6.1 (IN), U6.49 (PC3)
DO10: Q7.1 (IN), U6.48 (PC4)
DO11: Q8.1 (IN), U6.47 (PC5)
LUMINANCE: R109.1; also elsewhere on the board
unnamed: C51.1, D12.3 (C1A2), R105.2, R121.2, U13.9 (A)
unnamed: C53.1, D14.3 (C1A2), R107.2, R123.2, U13.7 (A)
unnamed: C52.1, D13.3 (C1A2), R106.2, R122.2, U13.8 (A)
unnamed: C60.1, D21.3 (C1A2), R119.2, R120.2, R130.2, U5.4 (A)
unnamed: C54.1, D15.3 (C1A2), R108.2, R124.2, U13.6 (A)
unnamed: C55.1, D16.3 (C1A2), R109.2, R110.2, R125.2, U13.5 (A)
unnamed: C56.1, D17.3 (C1A2), R111.2, R112.2, R126.2, U13.4 (A)
unnamed: C57.1, D18.3 (C1A2), R113.2, R114.2, R127.2, U13.3 (A)
unnamed: C58.1, D19.3 (C1A2), R115.2, R116.2, R128.2, U13.2 (A)
unnamed: C59.1, D20.3 (C1A2), R117.2, R118.2, R129.2, U5.5 (A)
OE: U5.1 (G1#), U13.1 (G1#); also elsewhere on the board
SPEED: R117.1; also elsewhere on the board

Notes on the sheet:
Lowside IPD 1A x 8ch
Lowside IPD 3A x 4ch
DIGITAL-IN 10ch
オン抵抗80mΩ 過電流制限値13A 出力クランプ電圧40V アクティブクランプ耐量200mJ
過電流制限値4.3A 出力クランプ電圧40V アクティブクランプ耐量500mJ
DIGITAL-OUT 8ch
Digital IN/OUT I/F
Rotary Enc-A
Rotary Enc-B
Push Switch-IN
fc = 4.8kHz

Notices in the files:
parts and their libraries:
COPYRIGHT: Copyright (C) 2024 Ultra Librarian. All rights reserved.
